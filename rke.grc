<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>garage</value></param>
<param><key>author</key><value>Roberto W. Nobrega</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>HT12E decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>433.92e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>433e6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>434e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>433.92e6</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>435e6</value></param>
<param><key>min</key><value>433e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sdr_rate / decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sdr_rate</value></param>
<param><key>value</key><value>1.8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>90</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_6026</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>1000</value></param>
<param><key>rate</key><value>1e-3</value></param>
<param><key>reference</key><value>0.333</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_2</value></param>
<param><key>const</key><value>-0.61</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/marcos/Documentos/TCC/ht6p20b.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>sdr_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.1</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=2, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name="ht6026",
            in_sig=[np.int8],
            out_sig=[np.int8])
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit1 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1])
        self.bit0 = np.array([0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0])
        self.bit2 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0])

        self.agreements = 0
        self.buffer_ = []  

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]
        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)
        bit0= np.array([0])
        in_stream =  np.concatenate((bit0,in_stream),axis=None)
        

        if len(in_stream) &lt; 352 or len(output_items[0]) &lt; 10:
            return 0
            
        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        #in_stream = in_stream[1:]
        #self.consume(0, 1)
        
        buffer_ = []
        while len(in_stream) &gt;= 16 and len(buffer_) &lt; 9:        

            seq3, in_stream = in_stream[:16], in_stream[16:]
            self.consume(0, 16)
            if np.all(seq3 == self.bit0):
                buffer_.append(0)
                
            elif np.all(seq3 == self.bit1):
                buffer_.append(1)
                
            elif np.all(seq3 == self.bit2):
                buffer_.append(2)    
                
            else:
                self.consume(0, 16 * (9 - len(buffer_)))
                return 0

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:9] = np.array(buffer_) + ord('0')
            output_items[0][9] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return 10
        else:
            return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>min_agreements</key><value>2</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=3, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Decoder for HT6P20',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit0 = np.array([0, 1, 1])
        self.bit1 = np.array([0, 0, 1])

        self.agreements = 0
        self.buffer_ = []

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]

        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)

        if len(in_stream) &lt; 100 or len(output_items[0]) &lt; 29:
            return 0

        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        in_stream = in_stream[1:]
        self.consume(0, 1)
        #print(in_stream)
        buffer_ = []
        flag=0
        while len(in_stream) &gt;= 3 and len(buffer_) &lt; 28:
            seq3, in_stream = in_stream[:3], in_stream[3:]
            self.consume(0, 3)
            if len(buffer_)&lt;24:  
                if np.all(seq3 == self.bit0):
                    buffer_.append(0)
                elif np.all(seq3 == self.bit1):
                    buffer_.append(1)
                else:
                    self.consume(0, 3 * (15 - len(buffer_)))
                    return 0
            else:
                if(flag==0):
                    if np.all(seq3 == self.bit0):
                        buffer_.append(0)           
                        flag = (flag != 1)   
                    else:
                        self.consume(0, 3 * (15 - len(buffer_)))
                        return 0
                elif(flag==1):
                    if np.all(seq3 == self.bit1):
                        buffer_.append(1)
                        flag = (flag != 1) 
                    else:
                        self.consume(0, 3 * (15 - len(buffer_)))
                        return 0    

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:28] = np.array(buffer_) + ord('0')
            output_items[0][28] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return 29
        else:
            return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>min_agreements</key><value>3</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>np.ones(sps) / (sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ht12e_dec</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=3, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Decoder for HT12E',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit0 = np.array([0, 1, 1])
        self.bit1 = np.array([0, 0, 1])

        self.agreements = 0
        self.buffer_ = []

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]

        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)

        if len(in_stream) &lt; 100 or len(output_items[0]) &lt; 13:
            return 0

        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        in_stream = in_stream[1:]
        self.consume(0, 1)
        print(in_stream)
        buffer_ = []
        while len(in_stream) &gt;= 3 and len(buffer_) &lt; 12:
            seq3, in_stream = in_stream[:3], in_stream[3:]
            self.consume(0, 3)
            if np.all(seq3 == self.bit0):
                buffer_.append(0)
            elif np.all(seq3 == self.bit1):
                buffer_.append(1)
            else:
                self.consume(0, 3 * (15 - len(buffer_)))
                return 0

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:12] = np.array(buffer_) + ord('0')
            output_items[0][12] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return 13
        else:
            return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>min_agreements</key><value>3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>ant0</key><value>00</value></param>
<param><key>bb_gain0</key><value>10</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>10</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sdr_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>peak_hold</key><value>True</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate*10</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0.2e-3</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0.2</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>blocks_add_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_2</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_2</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_2</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>ht12e_dec</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ht12e_dec</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
