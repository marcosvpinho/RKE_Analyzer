<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>garage</value></param>
<param><key>author</key><value>Marcos</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>RKE Analyzer</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_n</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq</value></param>
<param><key>block_id</key><value>crossing</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_name</key><value>freq</value></param>
<param><key>value</key><value>292000000</value></param>
<param><key>poll_rate</key><value>0.05</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>292e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>291e6</value></param>
<param><key>step</key><value>5000</value></param>
<param><key>stop</key><value>433.92e6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freqz</value></param>
<param><key>block_id</key><value>crossing</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_name</key><value>freqs</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>my_encoder</value></param>
<param><key>block_id</key><value>detectorx</value></param>
<param><key>function_name</key><value>retorna_codificador_detectado</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>my_seq</value></param>
<param><key>block_id</key><value>detectorx</value></param>
<param><key>function_name</key><value>retorna_sequencia_detectada</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sdr_rate / decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sdr_rate</value></param>
<param><key>value</key><value>1.8e6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>sps</value></param>
<param><key>block_id</key><value>probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>89</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>45</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>3</value></param>
<param><key>stop</key><value>80</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>sps1</value></param>
<param><key>block_id</key><value>crossing</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_name</key><value>retorna_sps</value></param>
<param><key>value</key><value>45</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>sps</value></param>
<param><key>label</key><value>sps</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>sps1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Sp1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1</value></param>
<param><key>value</key><value>my_encoder</value></param>
<param><key>label</key><value>Codigo</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0</value></param>
<param><key>value</key><value>my_seq</value></param>
<param><key>label</key><value>Quadro</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_2</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>freeq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fft_n</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/marcospinho/Downloads/ht6026_samp_freq_1.8M.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_n</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_n</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>crossing</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
from __future__ import division
import numpy as np
from gnuradio import gr


class crossing(gr.basic_block):

    def __init__(self):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='crossing zero',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        self.count = 0
        self.fs = 180000
        self.sps = 0
        self.ativo = 0
        self.flag = False
        self.list_frq = [292000000,433920000]
        self.pos = 0

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]
        ## cruzamentos por zero
        zero_crossings = np.where(np.diff(np.signbit(input_items)))
        size = len(zero_crossings[1])
        zeros_ = []
        zeros_ativo = []

        for x in range(0,size-2):
            dif = zero_crossings[1][x+1] - zero_crossings[1][x]
            #pegando apenas diferencas maiores que 5 amostras
            zeros_ativo.append(dif) 
            if dif &gt; 20:
        	   zeros_.append(dif)

        ## pegando o menor valor
        if (len(zeros_)):
            minimo = min(zeros_)
            valor = 1/(minimo/self.fs)
            self.sps = self.fs/valor
        else:
            self.sps = 0

        if (len(zeros_ativo)):
            minimo = min(zeros_ativo)
            valor = 1/(minimo/self.fs)
            self.ativo = self.fs/valor
        else:
            self.ativo = 0


        i0 = len(in_stream)
        self.consume(0, i0)
        #output_items[0][:1] = np.array(buffer_)
        return len(output_items[0])

        
    def retorna_sps(self):
        if(self.sps &lt; 10):
            return 10
        else:
            return int(self.sps)

    def ativo(self):
        if(self.ativo&gt;30):
            return True
        else:
            return False

    def freq(self):

        if(crossing.ativo(self)):
            return self.list_frq[self.pos]
        else:
            
            if(self.pos &lt;= len(self.list_frq)-1):
                val = self.list_frq[self.pos]
                self.pos = self.pos +1
                return val

            else:
                self.pos = 0
                val = self.list_frq[self.pos]
                return val
</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>detector</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blkdecoder(gr.basic_block):
    def __init__(self):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Decoder',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.buffer_ = []
        self.codificador = "Not Detected"
        self.seq = []
        self.replacements = []
        self.packet = []

    def retorna_sequencia_detectada(self):
        return self.seq

    def retorna_codificador_detectado(self):
        return self.codificador
    def replacement(self,replacements, in_stream):

        max_length = max([len(before) for before, after in replacements] + [0])
        ii = 0
        oo = 0
        buffer_ = []
        while ii + max_length &lt; len(in_stream):
            for before, after in replacements:
                if np.all(in_stream[ii : ii + len(before)] == before):
                    buffer_.append(after)
                    ii += len(before)
                    oo += 1
                    break
            else:
                ii += 1

        self.packet[:] = buffer_

        return 0

    def checker(self,in_stream,pos):

        len_stream = len(in_stream)
        flag = 0    

        if(pos == 0):
            for i in range(0,len_stream):
                if(in_stream[i] == 32 and flag == 0):
                    flag = 1

                elif(flag &gt; 0 and flag &lt;= 9 and in_stream[i] != 32):
                    self.buffer_.append(in_stream[i])
                    flag = flag + 1

                elif(flag == 10):
                    self.codificador = "HT6026"
                    self.seq = self.buffer_[0:10]
                    flag = 0
                    return True

                else:
                    flag = 0
                    self.buffer_ = []

            return False

        else:
            for i in range(0,len_stream -1):

                if(in_stream[i] == 32 and flag == 0):
                    flag = 1

                elif(flag &gt; 0 and flag &lt; 28 and in_stream[i] != 32):
                    self.buffer_.append(in_stream[i])
                    flag = flag + 1

                    if(flag == 12 and in_stream[i+1] == 32):
                        self.codificador = "HT12E"
                        self.seq = self.buffer_[0:13]
                        flag = 0
                        self.consume(0,len_stream0)
                        self.consume(1,len_stream1)
                        return True

                    elif(flag == 28 and in_stream1[i+1] == 32):
                        self.codificador = "HT6p20b"
                        self.seq = self.buffer_[0:29]
                        flag = 0
                        self.consume(0,len_stream0)
                        self.consume(1,len_stream1)
                        return True    
                else:
                    flag = 0
                    self.buffer_=[]

            return False


    def general_work(self, input_items, output_items):

        in_stream = input_items[0]
        if(len(input_items[0]) &lt; 300):
            return 0
        cert = []
        self.replacements.append([((0,0,0,0,0,0,0,1), 32), ((0,1,1), 48), ((0,0,1), 49)])
        self.replacements.append([((0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0), 32),((0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1), 46),((0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0), 49),((0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0), 50)])
        
        for i in range(0,1):
            blkdecoder.replacement(self,self.replacements[i], in_stream)
            if(blkdecoder.checker(self,self.packet,i)):
                self.consume(0,len(input_items[0]))

            else:
                self.consume(0,len(input_items[0]))

        return 0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>detectorx</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blkfinal(gr.basic_block):
    def __init__(self):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Decoder',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.buffer_ = []
        self.codificador = "Not Detected"
        self.seq = []
        self.replacements = []
        self.replacementsize = []
        self.packet = []
        self.replacements.append(([((0,0,0,0,0,0,0,1), 32), ((0,1,1), 48), ((0,0,1), 49)]))
        self.replacements.append(([((0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0), 32),((0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1), 46),((0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0), 49),((0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0), 50)]))
        self.replacementsize.append(28)
        self.replacementsize.append(9)

    def retorna_sequencia_detectada(self):
        return self.seq

    def retorna_codificador_detectado(self):
        return self.codificador
    def replacement(self,replacements, input_items,tam):

		# print("replacements",replacements)
		# print("tamanho",tam)

		#print(input_items)
		max_length = max([len(before) for before, after in replacements] + [0])
		size = len(input_items)
		if(size &lt; max_length):
			return 0
		ii = 0
		oo = 0
		buffer_ = []
		while ii + max_length &lt; len(input_items):
			for before, after in replacements:
				#print(input_items[ii : ii + len(before)],"-------------",before)
				if np.all(input_items[ii : ii + len(before)] == before):
					buffer_.append(after)
					ii += len(before)
					oo += 1
					break
			else:
				buffer_.append(32)
				oo += 1
				ii += 1
		size_b = len(buffer_)
		flag = 0
		pos = 0
		seq = np.zeros((tam),dtype=np.int8)
		for i in range(0,size_b):
			if(buffer_[i] == 32 and flag == 0 ):
				flag = 1

			elif(buffer_[i]!= 32 and flag ==1):
				seq[pos] = buffer_[i]
				pos=pos+1
				if(pos==tam):
					flag=2

			elif(flag == 2 and buffer_[i]==32):
				self.seq = seq[:]
				return tam
			else:
				pos  = 0
				flag = 0
				seq  = np.zeros((tam),dtype=np.int8)


		return 0



    def general_work(self, input_items, output_items):

		in_stream = input_items[0]
		if(len(input_items[0]) &lt; 200):
			return 0
		cert = []

		for i in range(0,len(self.replacements)):
			cod = blkfinal.replacement(self,self.replacements[i], in_stream,self.replacementsize[i])
			if(cod ==12):
				self.codificador= "HT12E"
			elif(cod ==28):
				self.codificador="HT6P20B"
			elif(cod==9):
				self.codificador="HT6026"
				
				

            #print(len(self.buffer_))

            # if(blkfinal.checker(self,self.packet,i)):
            #     print(blkfinal.retorna_sequencia_detectada(self))
            #     print(blkfinal.retorna_codificador_detectado(self))
            #     self.consume(0,len(input_items[0]))

            # else:
		self.consume(0,len(input_items[0]))

		return 0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ted_gain</key><value>0.01</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.1</value></param>
<param><key>max_dev</key><value>5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>ted_type</key><value>digital.TED_ZERO_CROSSING</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>divide</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class divide(gr.sync_block):
	def __init__(self):  # only default arguments here
		gr.sync_block.__init__(
        	self,
        	name='Divide',
        	in_sig=[np.float32],
        	out_sig=[np.float32],
        )
		self.maximum = 0.0
		self.flag = 0.0


	def work(self, input_items, output_items):
		
		
		in_stream = input_items[0][:]
		size = np.shape(in_stream)[0]
		self.maximum = np.maximum.reduce(in_stream)
		if(self.maximum &lt; 0.01):
			output_items[0][:] = np.zeros((size),dtype=np.float32)				
			self.consume(0,size)
			return len(output_items[0])
		#	self.maximum = 0.1
		#print(in_stream)
		#print(self.maximum)
		out = np.zeros((size),dtype=np.float32)
		for i in range(0,size):

			out[i]=in_stream[i]/self.maximum

			

		
		output_items[0][:] = out[:]

		return len(output_items[0])


	def retorna_maximo(self):
		return self.maximum
</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=2, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name="ht6026",
            in_sig=[np.int8],
            out_sig=[np.int8])
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit1 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1])
        self.bit0 = np.array([0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0])
        self.bit2 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0])

        self.agreements = 0
        self.buffer_ = []  

    def general_work(self, input_items, output_items):
        size = np.shape(input_items)[0]
        in_stream = np.zeros((size),dtype=np.int8)	
        in_stream = input_items[0][:]
        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)
        bit= np.array([0])
        in_stream =  np.concatenate((bit,in_stream),axis=None)
        


        if len(in_stream) &lt; 352 or len(output_items[0]) &lt; 10:
            return 0
            
        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        #in_stream = in_stream[1:]
        #self.consume(0, 1)
        
        buffer_ = []
        while len(in_stream) &gt;= 16 and len(buffer_) &lt; 9:        

            seq3, in_stream = in_stream[:16], in_stream[16:]
            self.consume(0, 16)
            if np.all(seq3 == self.bit0):
                buffer_.append(0)
                
            elif np.all(seq3 == self.bit1):
                buffer_.append(1)
                
            elif np.all(seq3 == self.bit2):
                buffer_.append(2)    
                
            else:
                print("errou")
                self.consume(0, 16 * (10 - len(buffer_)))
                return 0

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:9] = np.array(buffer_) + ord('0')
            output_items[0][9] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return len(output_items)
        else:
            return len(output_items)
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>min_agreements</key><value>1</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=3, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Decoder for HT6P20',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit0 = np.array([0, 1, 1])
        self.bit1 = np.array([0, 0, 1])

        self.agreements = 0
        self.buffer_ = []

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]
        size = np.shape(in_stream)[0]

        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
            
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)

        if len(in_stream) &lt; 100 or len(output_items[0]) &lt; 29:
            return 0

        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        in_stream = in_stream[1:]
        self.consume(0, 1)
        #print(in_stream)
        buffer_ = []
        flag=0
        while len(in_stream) &gt;= 3 and len(buffer_) &lt; 28:
            seq3, in_stream = in_stream[:3], in_stream[3:]
            self.consume(0, 3)
            if len(buffer_)&lt;24:  
                if np.all(seq3 == self.bit0):
                    buffer_.append(0)
                elif np.all(seq3 == self.bit1):
                    buffer_.append(1)
                else:
                    self.consume(0,size - (3* len(buffer_)))
                    return len(output_items[0])
            else:
                if(flag==0):
                    if np.all(seq3 == self.bit0):
                        buffer_.append(0)           
                        flag = (flag != 1)   
                    else:
                        self.consume(0,size - (3* len(buffer_)))
                        return len(output_items[0])
                elif(flag==1):
                    if np.all(seq3 == self.bit1):
                        buffer_.append(1)
                        flag = (flag != 1) 
                    else:
                        self.consume(0,size - (3* len(buffer_)))
                        return len(output_items[0]) 

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:28] = np.array(buffer_) + ord('0')
            output_items[0][28] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return len(output_items[0])
        else:
            return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>min_agreements</key><value>3</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_3</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk_cod(gr.basic_block):
    def __init__(self, debug=True, sps=0):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name="ht6026",
            in_sig=[np.int8],
            out_sig=[np.int8])

        
        # self.bit1 = np.array([0, 1, 1])
        # self.bit0 = np.array([0, 0, 1])
        # self.synt = np.array([0, 0, 0, 0, 0, 0, 0, 0, 1])
        self.sps  = sps
        self.sync = np.array([0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0])
        self.bit1 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1])
        self.bit0 = np.array([0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0])
        self.bit2 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0])
        self.pilot = 0
        self.buffer_ = []

    def general_work(self, input_items, output_items):
    	size_input = len(input_items[0][:])
    	if len(input_items[0][:]) &lt; 160:
            return 0

        ### se ativo 
        if(self.sps):
        	in_stream = input_items[0][:]
        else:
        	self.consume(0,size_input)
        	return 0         
        buffer_ = []
        while(True):

            if(len(in_stream) &lt; 16 ):
            	size = len(buffer_)
            	output_items[0] = np.zeros((size),dtype=np.int8)
                output_items[0][:] = np.array(buffer_)


                self.consume(0,size_input)
                return len(output_items[0])

            seq3, in_stream = in_stream[:16], in_stream[16:]
            
            if np.all(seq3 == self.sync):
                i=0
            else :
                if np.all(seq3 == self.bit0):
                    buffer_.append(0)

                elif np.all(seq3 == self.bit1):
                    buffer_.append(1)  

                elif np.all(seq3 == self.bit2):
                    buffer_.append(2)
                    

</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sps</key><value>minha_var</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_3_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk_cod(gr.basic_block):
    def __init__(self, debug=True, sps=0):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name="ht6p20b",
            in_sig=[np.int8],
            out_sig=[np.int8])

        
        self.bit1 = np.array([0, 1, 1])
        self.bit0 = np.array([0, 0, 1])
        self.sync = np.array([0, 0, 0, 0, 0, 0, 0, 0, 1])
        self.sps  = sps
        # self.sync = np.array([0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0])
        # self.bit1 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1])
        # self.bit0 = np.array([0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0])
        # self.bit2 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0])
        self.pilot = 0
        self.buffer_ = []

    def general_work(self, input_items, output_items):
        size_input = len(input_items[0][:])
        if len(input_items[0][:]) &lt; 160:
            return 0

        ### se ativo 
        if(self.sps):
            in_stream = input_items[0][:]
        else:
            self.consume(0,size_input)
            return 0         
        buffer_ = []

        while(True):

            if(len(in_stream) &lt; 3 ):
                size = len(buffer_)
                output_items[0] = np.zeros((size),dtype=np.int8)
                output_items[0][:] = np.array(buffer_)
                print(output_items[0])
                self.consume(0,size_input)
                return len(output_items[0])

            seq3 = in_stream[:9]
            
            if np.all(seq3 == self.sync):
                i=1
                in_stream = in_stream[9:]
                buffer_.append(5)
            else :
                seq3 = in_stream[:3]
                in_stream = in_stream[3:]
                if np.all(seq3 == self.bit0):
                    buffer_.append(0)

                elif np.all(seq3 == self.bit1):
                    buffer_.append(1)  
                    

</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sps</key><value>minha_var</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_3_0_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blkht6026(gr.basic_block):
    def __init__(self):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='My Replacement0',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        #self.replacements = [((0,0,0,0,0,0,0,1), 32), ((0,1,1), 48), ((0,0,1), 49)]
        self.replacements =[((0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0), 32),((0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1), 46),((0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0), 49),((0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0), 50)]


    def general_work(self, input_items, output_items):

        if(len(input_items[0]) &lt; 300):
            return 0
        max_length = max([len(before) for before, after in self.replacements] + [0])
        ii = 0
        oo = 0
        buffer_ = []
        while ii + max_length &lt; len(input_items[0]):
            for before, after in self.replacements:
                if np.all(input_items[0][ii : ii + len(before)] == before):
                    #output_items[0][oo] = after
                    buffer_.append(after)
                    ii += len(before)

                    oo += 1
                    break
            else:
                ii += 1
        output_items[0][:len(buffer_)] = np.array(buffer_)
        print("ht6026:", output_items[0])
        self.consume(0, ii)
        return oo</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_3_0_0_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blkht6026(gr.basic_block):
    def __init__(self):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='My Replacement2',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.replacements = [((0,0,0,0,0,0,0,0,1), 32), ((0,1,1), 48), ((0,0,1), 49)]
        #self.replacements =[((0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0), 32),((0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1), 46),((0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0), 49),((0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0), 50)]


    def general_work(self, input_items, output_items):
        if(len(input_items[0]) &lt; 300):
            return 0

        max_length = max([len(before) for before, after in self.replacements] + [0])
        ii = 0
        oo = 0
        buffer_ = []
        while ii + max_length &lt; len(input_items[0]):
            for before, after in self.replacements:
                if np.all(input_items[0][ii : ii + len(before)] == before):
                    #output_items[0][oo] = after
                    buffer_.append(after)
                    ii += len(before)

                    oo += 1
                    break
            else:
                ii += 1
        output_items[0][:len(buffer_)] = np.array(buffer_)
        self.consume(0, ii)
        return oo</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft</value></param>
<param><key>fft_size</key><value>fft_n</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_n)</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>np.ones(sps) / (sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ht12e_dec</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=3, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Decoder for HT12E',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit0 = np.array([0, 1, 1])
        self.bit1 = np.array([0, 0, 1])

        self.agreements = 0
        self.buffer_ = []

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]

        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)

        if len(in_stream) &lt; 100 or len(output_items[0]) &lt; 13:
            return 0

        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        in_stream = in_stream[1:]
        self.consume(0, 1)
        #print(in_stream)
        buffer_ = []
        while len(in_stream) &gt;= 3 and len(buffer_) &lt; 12:
            seq3, in_stream = in_stream[:3], in_stream[3:]
            self.consume(0, 3)
            if np.all(seq3 == self.bit0):
                buffer_.append(0)
            elif np.all(seq3 == self.bit1):
                buffer_.append(1)
            else:
                self.consume(0, 3 * (15 - len(buffer_)))
                return 0

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:12] = np.array(buffer_) + ord('0')
            output_items[0][12] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return 13
        else:
            return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>min_agreements</key><value>3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>sdr_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>50</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>ant0</key><value>00</value></param>
<param><key>bb_gain0</key><value>10</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>10</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sdr_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>sumx</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class summ(gr.sync_block):
	def __init__(self):  # only default arguments here
		gr.sync_block.__init__(
        	self,
        	name='Sum',
        	in_sig=[np.float32],
        	out_sig=[np.float32],
        )


	def work(self, input_items, output_items):
		
		
		in_stream = input_items[0][:]
		somar = np.log10(sum(in_stream)/10)
		print(somar)
		size = len(in_stream)			
		self.consume(0,size)

		
		return len(output_items[0])

</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>1,0,10,1</value></param>
<param><key>label0</key><value>Tab 0</value></param>
<param><key>label1</key><value>Tab 1</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>crossing</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>divide</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>sumx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crossing</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detectorx</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>detectorx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_float_to_int_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sumx</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
