<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>garage</value></param>
<param><key>author</key><value>Marcos</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>RKE Analyzer</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>292e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>292e6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>433.92e6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>minha_var</value></param>
<param><key>block_id</key><value>divide</value></param>
<param><key>function_name</key><value>retorna_maximo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sdr_rate / decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sdr_rate</value></param>
<param><key>value</key><value>1.8e6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>sps</value></param>
<param><key>block_id</key><value>probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>45</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>45</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>3</value></param>
<param><key>stop</key><value>90</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>72</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_6026</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>minha_var</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>sps</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/marcospinho/Documentos/TCC/RKE_Analyzer/ht6026_samp_freq_1.8M.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>ted_gain</key><value>0.01</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.1</value></param>
<param><key>max_dev</key><value>20</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>ted_type</key><value>digital.TED_ZERO_CROSSING</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>divide</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class divide(gr.sync_block):
	def __init__(self):  # only default arguments here
		gr.sync_block.__init__(
        	self,
        	name='Divide',
        	in_sig=[np.float32],
        	out_sig=[np.float32],
        )
		self.maximum = 0.0
		self.flag = 0.0


	def work(self, input_items, output_items):
		
		
		in_stream = input_items[0][:]
		size = np.shape(in_stream)[0]
		self.maximum = np.maximum.reduce(in_stream)
		if(self.maximum &lt; 0.05):
			output_items[0][:] = np.zeros((size),dtype=np.float32)				
			self.consume(0,size)
			return len(output_items[0])
		#	self.maximum = 0.1
		#print(in_stream)
		#print(self.maximum)
		out = np.zeros((size),dtype=np.float32)
		for i in range(0,size):

			out[i]=in_stream[i]/self.maximum

			

		
		output_items[0][:] = out[:]

		return len(output_items[0])


	def retorna_maximo(self):
		return self.maximum
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=2, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name="ht6026",
            in_sig=[np.int8],
            out_sig=[np.int8])
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit1 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1])
        self.bit0 = np.array([0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0])
        self.bit2 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0])

        self.agreements = 0
        self.buffer_ = []  

    def general_work(self, input_items, output_items):
        size = np.shape(input_items)[0]
        in_stream = np.zeros((size),dtype=np.int8)	
        in_stream = input_items[0][:]
        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)
        bit= np.array([0])
        in_stream =  np.concatenate((bit,in_stream),axis=None)
        


        if len(in_stream) &lt; 352 or len(output_items[0]) &lt; 10:
            return 0
            
        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        #in_stream = in_stream[1:]
        #self.consume(0, 1)
        
        buffer_ = []
        while len(in_stream) &gt;= 16 and len(buffer_) &lt; 9:        

            seq3, in_stream = in_stream[:16], in_stream[16:]
            self.consume(0, 16)
            if np.all(seq3 == self.bit0):
                buffer_.append(0)
                
            elif np.all(seq3 == self.bit1):
                buffer_.append(1)
                
            elif np.all(seq3 == self.bit2):
                buffer_.append(2)    
                
            else:
                print("errou")
                self.consume(0, 16 * (10 - len(buffer_)))
                return 0

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:9] = np.array(buffer_) + ord('0')
            output_items[0][9] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return len(output_items)
        else:
            return len(output_items)
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>min_agreements</key><value>1</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=3, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Decoder for HT6P20',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit0 = np.array([0, 1, 1])
        self.bit1 = np.array([0, 0, 1])

        self.agreements = 0
        self.buffer_ = []

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]
        size = np.shape(in_stream)[0]

        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
            
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)

        if len(in_stream) &lt; 100 or len(output_items[0]) &lt; 29:
            return 0

        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        in_stream = in_stream[1:]
        self.consume(0, 1)
        #print(in_stream)
        buffer_ = []
        flag=0
        while len(in_stream) &gt;= 3 and len(buffer_) &lt; 28:
            seq3, in_stream = in_stream[:3], in_stream[3:]
            self.consume(0, 3)
            if len(buffer_)&lt;24:  
                if np.all(seq3 == self.bit0):
                    buffer_.append(0)
                elif np.all(seq3 == self.bit1):
                    buffer_.append(1)
                else:
                    self.consume(0,size - (3* len(buffer_)))
                    return len(output_items[0])
            else:
                if(flag==0):
                    if np.all(seq3 == self.bit0):
                        buffer_.append(0)           
                        flag = (flag != 1)   
                    else:
                        self.consume(0,size - (3* len(buffer_)))
                        return len(output_items[0])
                elif(flag==1):
                    if np.all(seq3 == self.bit1):
                        buffer_.append(1)
                        flag = (flag != 1) 
                    else:
                        self.consume(0,size - (3* len(buffer_)))
                        return len(output_items[0]) 

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:28] = np.array(buffer_) + ord('0')
            output_items[0][28] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return len(output_items[0])
        else:
            return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>min_agreements</key><value>3</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
from __future__ import division
import numpy as np
from gnuradio import gr


class crossing(gr.basic_block):


    def __init__(self):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='crossing',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        self.count = 0
        self.fs = 180000
        

    def general_work(self, input_items, output_items):
        
        in_stream = input_items[0][:]
        #print(in_stream)
        zero_crossings = np.where(np.diff(np.signbit(input_items)))
        size = len(zero_crossings[1])
        zeros_ = []
        for x in range(0,size-2):
        	zeros_.append(zero_crossings[1][x+1] - zero_crossings[1][x])
        if (len(zeros_)):
            minimo = min(zeros_)
            valor = 1/(minimo/self.fs)
            print(valor)
        i0 = len(in_stream)
        self.consume(0, i0)
        #output_items[0][:] = np.zeros((size),dtype=np.float32)
        return len(output_items[0])

        







</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_3</value></param>
<param><key>_source_code</key><value>#!/usr/bin/python
# -*- coding: latin-1 -*-
import os, sys
import numpy as np
from gnuradio import gr

class decodicador(gr.basic_block):
    def __init__(self, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name="ht6026",
            in_sig=[np.int8],
            out_sig=[np.int8])
        
        self.syn  = np.array([0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0])  
        self.bit1 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1])
        self.bit0 = np.array([0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0])
        self.bit2 = np.array([0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0])


        

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]
        if len(in_stream) &lt; 16:
            return 0
        buffer_ = []
        
        while(True):
	        # sincronização ht6026
	        if(len(in_stream) &gt;= 16):   
	        	seq3 = in_stream[:16]
		        if np.all(seq3 == self.syn):
		            buffer_.append(5)
		            output_items[0][:1] = np.array(buffer_)
		            self.consume(0,16)
		            print("sync")
		            return len(output_items[0])

	        #### sincronização syncht6p20
	        if(len(in_stream) &gt;= 16):   
		        seq3 = in_stream[:16]
		        if np.all(seq3 == self.bit1):
		            buffer_.append(1)
		            output_items[0][:1] = np.array(buffer_)
		            self.consume(0,16)
		            print("ht6026-1")
		            return len(output_items[0])

	        if(len(in_stream) &gt;= 16):
		        seq3 = in_stream[:16]
		        if np.all(seq3 == self.bit2):
		            buffer_.append(2)
		            output_items[0][:1] = np.array(buffer_)
		            self.consume(0,16)
		            print("ht6026-2")
		            return len(output_items[0])

			if(len(in_stream) &gt;= 16):
				seq3 = in_stream[:16]
				if np.all(seq3 == self.bit0):
					buffer_.append(0)
					output_items[0][:1] = np.array(buffer_)
					self.consume(0,16)
					print("ht6026-0")

			else:
				print(size(in_stream))
				in_stream = in_stream[1:]
				self.consume(0, len(in_stream))
				return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_3_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk_cod(gr.basic_block):
    def __init__(self, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name="ht6p20",
            in_sig=[np.int8],
            out_sig=[np.int8])

        self.bit0 =  np.array([0, 1, 1])
        self.bit1 =  np.array([0, 0, 1])
        self.sync =  np.array([0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1])
        self.zeros = np.array([0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0])
        self.pilot = 0

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]
        if len(in_stream) &lt; 13:
            return 0
        
        buffer_ = []     

        if(self.pilot == 0 ):
            seq3, in_stream = in_stream[:37], in_stream[37:]
        else:
            seq3, in_stream = in_stream[:3], in_stream[3:]

        while(1):

            if np.all(seq3 == self.sync):
                buffer_.append(5)
                output_items[0][:1] = np.array(buffer_)
                self.consume(0,37)
                print(self.pilot)
                print("sync")
                
                return len(output_items[0])
        
            elif np.all(seq3 == self.zeros):
                #buffer_.append(5)
                #output_items[0][:1] = np.array(buffer_)
                self.consume(0,37)
                self.pilot = 0
                return 0

            else:
                if np.all(seq3 == self.bit0):
                    buffer_.append(0)
                    output_items[0][:1] = np.array(buffer_)
                    self.consume(0,3)
                    print(self.pilot)
                    return len(output_items[0])
                    
                elif np.all(seq3 == self.bit1):
                    buffer_.append(1)
                    output_items[0][:1] = np.array(buffer_)
                    self.consume(0,3)
                    print(self.pilot)
                    return len(output_items[0])
                else:
                    in_stream = in_stream[1:]
                    seq3= in_stream[:3]
                    self.consume(0, 1)
                    self.pilot = 0
                    if (len(in_stream))&lt;3:
                        return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>np.ones(sps) / (sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ht12e_dec</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.basic_block):
    def __init__(self, min_agreements=3, debug=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Decoder for HT12E',
            in_sig=[np.int8],
            out_sig=[np.int8]
        )
        self.min_agreements = min_agreements
        self.debug = debug

        self.bit0 = np.array([0, 1, 1])
        self.bit1 = np.array([0, 0, 1])

        self.agreements = 0
        self.buffer_ = []

    def general_work(self, input_items, output_items):
        in_stream = input_items[0][:]

        nonzeros = np.flatnonzero(in_stream)
        if len(nonzeros) == 0:
            i0 = len(in_stream)
        else:
            i0 = nonzeros[0]
        # i0 = first nonzero input index.

        in_stream = in_stream[i0:]
        self.consume(0, i0)

        if len(in_stream) &lt; 100 or len(output_items[0]) &lt; 13:
            return 0

        # At this point, the first entry should necessarily be 1, and
        # we should have at least 100 input data items.

        in_stream = in_stream[1:]
        self.consume(0, 1)
        #print(in_stream)
        buffer_ = []
        while len(in_stream) &gt;= 3 and len(buffer_) &lt; 12:
            seq3, in_stream = in_stream[:3], in_stream[3:]
            self.consume(0, 3)
            if np.all(seq3 == self.bit0):
                buffer_.append(0)
            elif np.all(seq3 == self.bit1):
                buffer_.append(1)
            else:
                self.consume(0, 3 * (15 - len(buffer_)))
                return 0

        if buffer_ == self.buffer_:
            self.agreements += 1
        else:
            self.buffer_ = buffer_
            self.agreements = 0

        if self.agreements &gt; self.min_agreements:
            output_items[0][:12] = np.array(buffer_) + ord('0')
            output_items[0][12] = ord('\n')
            if self.debug:
                print(self.agreements, buffer_)
            return 13
        else:
            return 0
</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>min_agreements</key><value>3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>sdr_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>50</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>ant0</key><value>00</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sdr_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>1,0,10,1</value></param>
<param><key>label0</key><value>Tab 0</value></param>
<param><key>label1</key><value>Tab 1</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>epy_block_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>divide</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>epy_block_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>epy_block_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>ht12e_dec</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_float_to_int_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>divide</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_3</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_3_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
